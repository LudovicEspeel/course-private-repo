# Keil uVision project STCubeGenerated.uvprojx, settings and files
target STCubeGenerated (ARM-ADS)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STCubeGenerated +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c include: ../Inc;C:/Users/u0095800/STM32Cube/Repository/STM32Cube_FW_F7_V1.17.2/Drivers/STM32F7xx_HAL_Driver/Inc;C:/Users/u0095800/STM32Cube/Repository/STM32Cube_FW_F7_V1.17.2/Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;C:/Users/u0095800/STM32Cube/Repository/STM32Cube_FW_F7_V1.17.2/Drivers/CMSIS/Device/ST/STM32F7xx/Include;C:/Users/u0095800/STM32Cube/Repository/STM32Cube_FW_F7_V1.17.2/Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User
    ../Src/: main.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Drivers/STM32F7xx_HAL_Driver
    C:/Users/u0095800/STM32Cube/Repository/STM32Cube_FW_F7_V1.17.2/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_eth.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
software components: CMSIS:CORE 4.3.0
